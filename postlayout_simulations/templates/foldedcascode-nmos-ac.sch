** sch_path: postlayout_simulations/templates/foldedcascode-nmos-ac.sch
* (c) 2025 Thesis_HP, Apache-2.0 license
**.subckt foldedcascode-nmos-ac
Vss v_ss GND 0
Vdd v_dd GND CACE{vdd}
Vin v_in v_ss dc CACE{vin} ac 1
.save v(v_in)
I0 v_dd net1 CACE{ibias}
.save v(v_out)
x1 v_dd net1 v_out v_out v_in v_ss ota_final
**** begin user architecture code



.include /foss/designs/thesis/thesis_hp/postlayout_simulations/gds/ota_final.cir

.include CACE{DUT_path}
.temp CACE{temp}
.param mc_ok = CACE{sigma=1}
.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

.control
set num_threads=1

op
let dcgain=v(v_out)/v(v_in)

ac dec 101 10 100MEG
meas ac acgain MAX vmag(v_out) FROM=10 TO=100
let f3db = acgain/sqrt(2)
meas ac fbw WHEN vmag(v_out)=f3db FALL=1

echo $&op1.dcgain $&fbw > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



.lib cornerMOSlv.lib mos_CACE{corner_mos}
.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib $::SG13G2_MODELS/cornerCAP.lib cap_typ

**** end user architecture code
**.ends
.GLOBAL GND
.end
