** sch_path: cace/templates/foldedcascode-nmos-noise.sch
* (c) 2025 Thesis_HP, Apache-2.0 license
**.subckt foldedcascode-nmos-noise
Vss v_ss GND 0
Vdd v_dd GND CACE{vdd}
Vin v_in v_ss dc CACE{vin} ac 1
.save v(v_in)
I0 v_dd net1 CACE{ibias}
C1 v_out v_ss CACE{cload} m=1
.save v(v_out)
x1 v_dd v_in v_out v_out net1 v_ena v_ss foldedcascode_nmos
Venable v_ena v_ss 1.5
.save v(v_ena)
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.param mc_ok = CACE{sigma=1}
.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]
.option sparse

.control
set num_threads=1
save all
noise v(v_out) Vin dec 101 1k 100MEG

let noise=onoise_total
echo $&noise > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



.lib cornerMOSlv.lib mos_CACE{corner_mos}
.lib cornerMOShv.lib mos_CACE{corner_mos}

**** end user architecture code
**.ends

* expanding   symbol:  foldedcascode_nmos.sym # of pins=7
** sym_path: Designs/otas/foldedcascode_nmos.sym
** sch_path: Designs/otas/foldedcascode_nmos.sch
.subckt foldedcascode_nmos AVDD PLUS MINUS Vout Ibias d_ena AVSS
*.ipin PLUS
*.ipin MINUS
*.opin Vout
*.ipin AVDD
*.ipin AVSS
*.ipin Ibias
*.ipin d_ena
XM1 net5 PLUS net1 AVSS sg13_lv_nmos w=5u l=1u ng=1 m=1 mm_ok=1
XMt net11 Ibias AVSS AVSS sg13_lv_nmos w=5.5u l=5u ng=3 m=1 mm_ok=1
XM4 net3 net4 AVSS AVSS sg13_lv_nmos w=1u l=0.5u ng=1 m=1 mm_ok=1
XM3 net2 net4 AVSS AVSS sg13_lv_nmos w=1u l=0.5u ng=1 m=1 mm_ok=1
XM2 net6 MINUS net1 AVSS sg13_lv_nmos w=5u l=1u ng=1 m=1 mm_ok=1
XM7 net4 net9 net2 AVSS sg13_lv_nmos w=1.5u l=0.5u ng=1 m=1 mm_ok=1
XM8 Vout net9 net3 AVSS sg13_lv_nmos w=1.5u l=0.5u ng=1 m=1 mm_ok=1
XM5 net4 net8 net5 AVDD sg13_lv_pmos w=6u l=0.5u ng=1 m=1 mm_ok=1
XM9 net5 net7 AVDD AVDD sg13_lv_pmos w=6u l=0.5u ng=1 m=1 mm_ok=1
XM6 Vout net8 net6 AVDD sg13_lv_pmos w=6u l=0.5u ng=1 m=1 mm_ok=1
XM0 net6 net7 AVDD AVDD sg13_lv_pmos w=6u l=0.5u ng=1 m=1 mm_ok=1
XMb Ibias Ibias AVSS AVSS sg13_lv_nmos w=4u l=5u ng=2 m=1 mm_ok=1
XM11 net8 net8 net7 AVDD sg13_lv_pmos w=6u l=0.5u ng=2 m=1 mm_ok=1
XM12 net7 net7 AVDD AVDD sg13_lv_pmos w=6u l=0.5u ng=2 m=1 mm_ok=1
XM13 net12 net7 AVDD AVDD sg13_lv_pmos w=6u l=0.5u ng=2 m=1 mm_ok=1
XM14 net9 net9 AVSS AVSS sg13_lv_nmos w=1.5u l=0.5u ng=1 m=1 mm_ok=1
XMb1 net10 Ibias AVSS AVSS sg13_lv_nmos w=4u l=5u ng=2 m=1 mm_ok=1
Vmeas net8 net10 0
.save i(vmeas)
Vmeas1 net1 net11 0
.save i(vmeas1)
Vmeas2 net12 net9 0
.save i(vmeas2)
XMdecoup1 AVSS Ibias AVSS AVSS sg13_lv_nmos w=8u l=1u ng=4 m=1 mm_ok=1
XMdecoup2 AVSS net9 AVSS AVSS sg13_lv_nmos w=8u l=1u ng=4 m=1 mm_ok=1
XMdecoup3 AVDD net7 AVDD AVDD sg13_lv_pmos w=12u l=0.5u ng=4 m=1 mm_ok=1
XMdecoup4 AVDD net8 AVDD AVDD sg13_lv_pmos w=12u l=0.5u ng=4 m=1 mm_ok=1
XMpd3 ena ena_n AVSS AVSS sg13_lv_nmos w=1u l=0.13u ng=1 m=1 mm_ok=1
XMpd4 ena ena_n AVDD AVDD sg13_lv_pmos w=1u l=0.13u ng=1 m=1 mm_ok=1
XMpd1 ena_n d_ena AVSS AVSS sg13_lv_nmos w=1u l=0.13u ng=1 m=1 mm_ok=1
XMpd2 ena_n d_ena AVDD AVDD sg13_lv_pmos w=1u l=0.13u ng=1 m=1 mm_ok=1
XMpd5 Ibias ena_n AVSS AVSS sg13_lv_nmos w=1u l=0.13u ng=1 m=1 mm_ok=1
XMpd6 Ibias ena Ibias AVSS sg13_lv_nmos w=1u l=0.13u ng=1 m=1 mm_ok=1
XMpd7 net7 ena AVDD AVDD sg13_lv_pmos w=1u l=0.13u ng=1 m=1 mm_ok=1
XMpd8 net8 ena AVDD AVDD sg13_lv_pmos w=1u l=0.13u ng=1 m=1 mm_ok=1
XMpd9 net4 ena_n AVSS AVSS sg13_lv_nmos w=1u l=0.13u ng=1 m=1 mm_ok=1
XMpd10 net9 ena_n AVSS AVSS sg13_lv_nmos w=1u l=0.13u ng=1 m=1 mm_ok=1
XMpd11 Vout ena_n AVSS AVSS sg13_lv_nmos w=1u l=0.13u ng=1 m=1 mm_ok=1
.ends

.GLOBAL GND
.end
