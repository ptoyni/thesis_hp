** sch_path: cace/templates/ota-5t-noise.sch
* (c) 2025 Thesis_HP, Apache-2.0 license
**.subckt ota-5t-noise
Vss v_ss GND 0
Vdd v_dd GND CACE{vdd}
Vin v_in v_ss dc CACE{vin} ac 1
.save v(v_in)
I0 v_dd net1 CACE{ibias}
C1 v_out v_ss CACE{cload} m=1
.save v(v_out)
x1 v_dd v_out net1 v_in v_out v_ss 5tota
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.param mc_ok = CACE{sigma=1}
.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]
.option sparse

.control
set num_threads=1
save all
noise v(v_out) Vin dec 101 1k 100MEG

let noise=onoise_total
echo $&noise > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



.lib cornerMOSlv.lib mos_CACE{corner}
.lib cornerMOShv.lib mos_CACE{corner}

**** end user architecture code
**.ends

* expanding   symbol:  /foss/designs/thesis/workspace/thesis_hp/designs/otas/5tota.sym # of pins=6
** sym_path: Designs/otas/1_schematics/5tota.sym
** sch_path: Designs/otas/1_schematics/5tota.sch
.subckt 5tota AVDD Vout Ibias PLUS MINUS AVSS
*.ipin PLUS
*.ipin MINUS
*.opin Vout
*.ipin AVDD
*.ipin AVSS
*.ipin Ibias
XM1 Vout MINUS net2 AVSS sg13_lv_nmos w=2u l=5u ng=1 m=1 mm_ok=1
XM3 net1 PLUS net2 AVSS sg13_lv_nmos w=2u l=5u ng=1 m=1 mm_ok=1
XM5 Vout net1 AVDD AVDD sg13_lv_pmos w=1.5u l=5u ng=1 m=1 mm_ok=1
XM7 net1 net1 AVDD AVDD sg13_lv_pmos w=1.5u l=5u ng=1 m=1 mm_ok=1
XM6 net2 Ibias AVSS AVSS sg13_lv_nmos w=0.5u l=5u ng=1 m=1 mm_ok=1
XM2 Ibias Ibias AVSS AVSS sg13_lv_nmos w=2.5u l=5u ng=1 m=1 mm_ok=1
XM4 Vout AVSS AVSS AVSS sg13_lv_nmos w=2u l=5u ng=1 m=1 mm_ok=1
XM8 Vout AVSS AVSS AVSS sg13_lv_nmos w=2u l=5u ng=1 m=1 mm_ok=1
XM9 net1 AVSS AVSS AVSS sg13_lv_nmos w=2u l=5u ng=1 m=1 mm_ok=1
XM10 net1 AVSS AVSS AVSS sg13_lv_nmos w=2u l=5u ng=1 m=1 mm_ok=1
XM11 net2 AVSS AVSS AVSS sg13_lv_nmos w=0.5u l=5u ng=1 m=1 mm_ok=1
XM12 Vout AVDD AVDD AVDD sg13_lv_pmos w=1.5u l=5u ng=1 m=1 mm_ok=1
XM13 net1 AVDD AVDD AVDD sg13_lv_pmos w=1.5u l=5u ng=1 m=1 mm_ok=1
.ends

.GLOBAL GND
.end
