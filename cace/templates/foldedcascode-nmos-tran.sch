** sch_path: cace/templates/foldedcascode-nmos-tran.sch
* (c) 2025 Thesis_HP, Apache-2.0 license
**.subckt foldedcascode-nmos-tran
Vss v_ss GND 0
Vdd v_dd GND CACE{vdd}
Vin v_in v_ss CACE{vin}
.save v(v_in)
I0 v_dd net1 dc 0 pwl(0 0 1.1u 0 1.2u CACE{ibias})
C1 v_out v_ss CACE{cload} m=1
.save v(v_out)
Venable v_ena v_ss dc 0 pwl(0 0 1u 0 1.1u CACE{vdd})
.save v(v_ena)
x1 v_dd net1 v_out v_out v_in v_ena v_ss foldedcascode_nmos
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.param mc_ok = CACE{sigma=1}
.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

.ic v(v_out)=0
.option method=gear

.control
set num_threads=1
tran 0.005u 15u uic

let vout_limit=CACE{vin}*0.99
meas tran tcross WHEN v(v_out)=vout_limit
let vena_limit=0.5*CACE{vdd}
meas tran tstart WHEN v(v_ena)=vena_limit
let tsettle=tcross-tstart

echo $&tsettle > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



.lib cornerMOSlv.lib mos_CACE{corner_mos}
.lib cornerMOShv.lib mos_CACE{corner_mos}

**** end user architecture code
**.ends
.GLOBAL GND
.end
