** sch_path: cace/templates/foldedcascode-ac.sch
* (c) 2025 Thesis_HP, Apache-2.0 license
**.subckt foldedcascode-ac
Vss v_ss GND 0
Vdd v_dd GND CACE{vdd}
Vin v_in v_ss dc CACE{vin} ac 1
.save v(v_in)
I0 v_dd net1 CACE{ibias}
C1 v_out v_ss CACE{cload} m=1
.save v(v_out)
x1 v_dd net1 v_in v_out v_out v_ss foldedcascode
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.param mc_ok = CACE{sigma=1}
.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

.control
set num_threads=1

op
let dcgain=v(v_out)/v(v_in)

ac dec 101 10 100MEG
meas ac acgain MAX vmag(v_out) FROM=10 TO=100
let f3db = acgain/sqrt(2)
meas ac fbw WHEN vmag(v_out)=f3db FALL=1

echo $&op1.dcgain $&fbw > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



.lib cornerMOSlv.lib mos_CACE{corner_mos}
.lib cornerMOShv.lib mos_CACE{corner_mos}

**** end user architecture code
**.ends

* expanding   symbol:  foldedcascode.sym # of pins=6
** sym_path: Designs/otas/foldedcascode.sym
** sch_path: Designs/otas/foldedcascode.sch
.subckt foldedcascode AVDD Ibias PLUS MINUS Vout AVSS
*.ipin AVDD
*.ipin AVSS
*.ipin PLUS
*.ipin MINUS
*.opin Vout
*.ipin Ibias
XMt2 net1 Ibias AVDD AVDD sg13_lv_pmos w=21u l=1u ng=3 m=1 mm_ok=1
XM1 net3 PLUS net1 AVDD sg13_lv_pmos w=19.5u l=1u ng=2 m=1 mm_ok=1
XM2 net8 MINUS net1 AVDD sg13_lv_pmos w=19.5u l=1u ng=2 m=1 mm_ok=1
XM6 net6 Vout AVDD AVDD sg13_lv_pmos w=3u l=0.5u ng=1 m=1 mm_ok=1
XM7 net5 net4 net6 AVDD sg13_lv_pmos w=5u l=0.5u ng=2 m=1 mm_ok=1
XM8 net7 Vout AVDD AVDD sg13_lv_pmos w=3u l=0.5u ng=1 m=1 mm_ok=1
XM15 Vout net4 net7 AVDD sg13_lv_pmos w=5u l=0.5u ng=2 m=1 mm_ok=1
XM16 Vout Ibias net8 AVSS sg13_lv_nmos w=1.5u l=0.5u ng=1 m=1 mm_ok=1
XM17 net8 net2 AVSS AVSS sg13_lv_nmos w=1.5u l=0.5u ng=1 m=1 mm_ok=1
XM18 net5 Ibias net3 AVSS sg13_lv_nmos w=1.5u l=0.5u ng=1 m=1 mm_ok=1
XM27 net3 net2 AVSS AVSS sg13_lv_nmos w=1.5u l=0.5u ng=1 m=1 mm_ok=1
XM28 Ibias Ibias AVDD AVDD sg13_lv_pmos w=15u l=1u ng=3 m=1 mm_ok=1
XM29 Ibias Ibias net2 AVSS sg13_lv_nmos w=3u l=0.5u ng=1 m=1 mm_ok=1
XM30 net2 net2 AVSS AVSS sg13_lv_nmos w=3u l=0.5u ng=1 m=1 mm_ok=1
XM31 AVDD Ibias net9 AVSS sg13_lv_nmos w=3u l=0.5u ng=1 m=1 mm_ok=1
XM32 net9 net2 AVSS AVSS sg13_lv_nmos w=3u l=0.5u ng=1 m=1 mm_ok=1
XM33 net4 net2 AVSS AVSS sg13_lv_nmos w=3u l=0.5u ng=1 m=1 mm_ok=1
XM34 net4 net4 AVDD AVDD sg13_lv_pmos w=10u l=0.5u ng=2 m=1 mm_ok=1
XMdecoup1 AVDD net4 AVDD AVDD sg13_lv_pmos w=12u l=0.5u ng=4 m=1 mm_ok=1
XMdecoup2 AVDD Ibias AVDD AVDD sg13_lv_pmos w=12u l=0.5u ng=4 m=1 mm_ok=1
XMdecoup3 AVSS Ibias AVSS AVSS sg13_lv_nmos w=8u l=1u ng=4 m=1 mm_ok=1
XMdecoup4 AVSS net2 AVSS AVSS sg13_lv_nmos w=8u l=1u ng=4 m=1 mm_ok=1
XMdecoup5 AVSS net2 AVSS AVSS sg13_lv_nmos w=8u l=1u ng=4 m=1 mm_ok=1
.ends

.GLOBAL GND
.end
