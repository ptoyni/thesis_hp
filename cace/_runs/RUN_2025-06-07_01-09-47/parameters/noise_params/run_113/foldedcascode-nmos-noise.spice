** sch_path: /foss/designs/thesis/workspace/thesis_hp/cace/_runs/RUN_2025-06-07_01-09-47/parameters/noise_params/run_113/foldedcascode-nmos-noise.sch
**.subckt foldedcascode-nmos-noise
Vss v_ss GND 0
Vdd v_dd GND 1.55
Vin v_in v_ss dc 0.8 ac 1
.save v(v_in)
I0 v_dd net1 9.999999999999999e-06
C1 v_out v_ss 2e-12 m=1
.save v(v_out)
x1 v_dd v_in v_out v_out net1 v_ss foldedcascode_nmos
**** begin user architecture code

.include /foss/designs/thesis/workspace/thesis_hp/cace/netlist/schematic/foldedcascode_nmos.spice
.temp -40
.param mc_ok = 1
.option SEED=12345
.option sparse

.control
set num_threads=1
save all
noise v(v_out) Vin dec 101 1k 100MEG

let noise=onoise_total
echo $&noise > /foss/designs/thesis/workspace/thesis_hp/cace/_runs/RUN_2025-06-07_01-09-47/parameters/noise_params/run_113/foldedcascode-nmos-noise_113.data
.endc

.lib cornerMOSlv.lib mos_ff
.lib cornerMOShv.lib mos_ff

**** end user architecture code
**.ends
.GLOBAL GND
.end
