** sch_path: /foss/designs/thesis/workspace/thesis_hp/cace/_runs/RUN_2025-06-07_01-16-52/parameters/ac_mc_params/run_0/run_2/foldedcascode-nmos-ac.sch
**.subckt foldedcascode-nmos-ac
Vss v_ss GND 0
Vdd v_dd GND 1.5
Vin v_in v_ss dc 0.8 ac 1
.save v(v_in)
I0 v_dd net1 9.999999999999999e-06
C1 v_out v_ss 2e-12 m=1
.save v(v_out)
x1 v_dd v_in v_out v_out net1 v_ss foldedcascode_nmos
**** begin user architecture code

.include /foss/designs/thesis/workspace/thesis_hp/cace/netlist/schematic/foldedcascode_nmos.spice
.temp 27
.param mc_ok = 1
.option SEED=12348

.control
set num_threads=1

op
let dcgain=v(v_out)/v(v_in)

ac dec 101 10 100MEG
meas ac acgain MAX vmag(v_out) FROM=10 TO=100
let f3db = acgain/sqrt(2)
meas ac fbw WHEN vmag(v_out)=f3db FALL=1

echo $&op1.dcgain $&fbw > /foss/designs/thesis/workspace/thesis_hp/cace/_runs/RUN_2025-06-07_01-16-52/parameters/ac_mc_params/run_0/run_2/foldedcascode-nmos-ac_0.data
.endc

.lib cornerMOSlv.lib mos_tt_stat
.lib cornerMOShv.lib mos_tt_stat

**** end user architecture code
**.ends
.GLOBAL GND
.end
